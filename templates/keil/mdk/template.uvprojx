# Keil uVision project template.uvprojx, settings and files
target AC6-flash (6160000::V6.16::ARMCLANG)
  device: ARMCM0P_MPU ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: template
  AfterMake: .\axf2uf2.bat
  c flags: Optim=6 OneElfS=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=3
  c define: PICO,__PICO_USE_LCD_1IN3__=0
  c misc: -include env_wrapper.h
  c include: ..\..\..\SDK\src\rp2040\hardware_structs\include;..\..\..\SDK\src\rp2_common\cmsis\include\cmsis;..\..\..\SDK\src\rp2_common\cmsis\stub\CMSIS\Device\RaspberryPi\RP2040\Include;..\..\..\SDK\src\boards\include\boards;..\..\..\SDK\src\rp2040\hardware_regs\include;.\wrapper;..\..\..\SDK\src\rp2_common\hardware_base\include;..\..\..\SDK\src\rp2_common\hardware_watchdog\include;..\..\..\SDK\src\rp2_common\hardware_pll\include;..\..\..\SDK\src\rp2_common\hardware_xosc\include;..\..\..\SDK\src\rp2_common\hardware_flash\include\;..\..\..\SDK\src\rp2_common\hardware_dma\include\;..\..\..\SDK\src\rp2_common\hardware_irq\include;..\..\..\SDK\src\rp2_common\hardware_gpio\include;..\..\..\SDK\src\rp2_common\hardware_resets\include;..\..\..\SDK\src\rp2_common\hardware_clocks\include;..\..\..\SDK\src\rp2_common\hardware_timer\include;..\..\..\SDK\src\rp2_common\hardware_sync\include;..\..\..\SDK\src\rp2_common\hardware_claim\include;..\..\..\SDK\src\rp2_common\hardware_spi\include;..\..\..\SDK\src\rp2_common\hardware_pwm\include;..\..\..\SDK\src\rp2_common\hardware_i2c\include;..\..\..\SDK\src\rp2_common\hardware_uart\include;..\..\..\SDK\src\rp2_common\hardware_adc\include;..\..\..\SDK\src\common\pico_base\include;..\..\..\SDK\src\rp2_common\pico_multicore\include;..\..\..\SDK\src\common\pico_sync\include;..\..\..\SDK\src\common\pico_time\include;..\..\..\SDK\src\common\pico_util\include;..\..\..\SDK\src\common\pico_stdlib\include;..\..\..\SDK\src\rp2_common\pico_stdio\include;..\..\..\SDK\src;..\..\..\SDK\src\rp2_common\pico_runtime\include;..\..\..\SDK\src\rp2_common\pico_printf\include;..\..\..\SDK\src\rp2_common\pico_bootrom\include;..\..\..\SDK\src\rp2_common\pico_stdio\include;..\..\..\SDK\src\rp2_common\pico_stdio_uart\include;..\..\..\SDK\src\rp2_common\pico_stdio_usb\include;..\..\..\SDK\src\common\pico_binary_info\include;..\..\..\SDK\src\rp2_common\pico_stdio_semihosting\include;..\bsp\Config;..\bsp\LCD;..\..\bsp
  asm define: PICO_MAX_SHARED_IRQ_HANDLERS=4,LIB_CMSIS_CORE=1,PICO_CMSIS_RENAME_EXCEPTIONS=1
  asm include: ..\..\..\SDK\src\rp2040\hardware_regs\include;..\..\..\SDK\src\rp2_common\hardware_irq\include;..\..\..\SDK\src\rp2_common\pico_platform\include;..\..\..\SDK\src\common\pico_base\include;.\wrapper\pico_base;..\..\..\SDK\src\rp2_common\boot_stage2\asminclude;..\..\..\SDK\src\rp2_common\boot_stage2\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\RP2040.sct
  link misc: --diag_suppress=L6170,L6314,L6306,L6329 --keep=compile_time_choice.o --entry=_stage2_boot
--keep=ram_vector_table
  group Pico-SDK
    ./: startup_RP2040.c
    ../../../SDK/src/rp2_common/cmsis/stub/CMSIS/Device/RaspberryPi/RP2040/Source/: system_RP2040.c
    ../../../SDK/src/rp2_common/hardware_clocks/: clocks.c
    ../../../SDK/src/rp2_common/hardware_watchdog/: watchdog.c
    ../../../SDK/src/rp2_common/hardware_pll/: pll.c
    ../../../SDK/src/rp2_common/pico_platform/: platform.c
    ../../../SDK/src/rp2_common/hardware_xosc/: xosc.c
    ../../../SDK/src/rp2_common/hardware_irq/: irq.c irq_handler_chain.S
    ../../../SDK/src/rp2_common/hardware_gpio/: gpio.c
    ../../../SDK/src/rp2_common/pico_multicore/: multicore.c
    ../../../SDK/src/rp2_common/hardware_sync/: sync.c
    ../../../SDK/src/common/pico_sync/: critical_section.c lock_core.c mutex.c sem.c
    ../../../SDK/src/common/pico_time/: time.c timeout_helper.c
    ../../../SDK/src/rp2_common/hardware_timer/: timer.c
    ../../../SDK/src/rp2_common/hardware_claim/: claim.c
    ../../../SDK/src/common/pico_util/: queue.c pheap.c datetime.c
    ../../../SDK/src/host/pico_stdlib/: stdlib.c
    ../../../SDK/src/rp2_common/hardware_uart/: uart.c
    ../../../SDK/src/rp2_common/boot_stage2/: compile_time_choice.S boot2_w25q080.S
    ./wrapper/: runtime.c
    ../../../SDK/src/rp2_common/pico_printf/: printf_none.S
    ../../../SDK/src/rp2_common/hardware_i2c/: i2c.c
    ../../../SDK/src/rp2_common/hardware_spi/: spi.c
    ../../../SDK/src/rp2_common/hardware_adc/: adc.c
    ../../../SDK/src/rp2_common/pico_bootrom/: bootrom.c
    ../../../SDK/src/rp2_common/pico_stdio_uart/: stdio_uart.c
    ../../../SDK/src/rp2_common/pico_standard_link/: binary_info.c
    ../../../SDK/src/rp2_common/hardware_flash/: flash.c
    ../../../SDK/src/rp2_common/hardware_dma/: dma.c
  group platform
    ./wrapper/: env_wrapper.h env_wrapper.c stdio.c
    ./wrapper/pico/: platform.h
    ./wrapper/hardware/: sync.h
  group Application
    ../: main.c
  group BSP
    ../bsp/LCD/: LCD_1in3.c LCD_1in3.h
    ../bsp/Config/: DEV_Config.c
target AC6-RunInSRAM (6160000::V6.16::ARMCLANG)
  device: ARMCM0P_MPU ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: template
  AfterMake: .\axf2uf2.bat
  c flags: Optim=7 OneElfS=1 v6Lang=6 v6LangP=3 wLevel=3
  c define: PICO,__PICO_USE_LCD_1IN3__=0
  c misc: -include env_wrapper.h
  c include: ..\..\..\SDK\src\rp2_common\hardware_flash\include\;..\..\..\SDK\src\rp2_common\hardware_dma\include\;..\..\..\SDK\src\rp2040\hardware_structs\include;..\..\..\SDK\src\rp2_common\cmsis\include\cmsis;..\..\..\SDK\src\rp2_common\cmsis\stub\CMSIS\Device\RaspberryPi\RP2040\Include;..\..\..\SDK\src\boards\include\boards;..\..\..\SDK\src\rp2040\hardware_regs\include;.\wrapper;..\..\..\SDK\src\rp2_common\hardware_base\include;..\..\..\SDK\src\rp2_common\hardware_watchdog\include;..\..\..\SDK\src\rp2_common\hardware_pll\include;..\..\..\SDK\src\rp2_common\hardware_xosc\include;..\..\..\SDK\src\rp2_common\hardware_irq\include;..\..\..\SDK\src\rp2_common\hardware_gpio\include;..\..\..\SDK\src\rp2_common\hardware_resets\include;..\..\..\SDK\src\rp2_common\hardware_clocks\include;..\..\..\SDK\src\rp2_common\hardware_timer\include;..\..\..\SDK\src\rp2_common\hardware_sync\include;..\..\..\SDK\src\rp2_common\hardware_claim\include;..\..\..\SDK\src\rp2_common\hardware_spi\include;..\..\..\SDK\src\rp2_common\hardware_pwm\include;..\..\..\SDK\src\rp2_common\hardware_i2c\include;..\..\..\SDK\src\rp2_common\hardware_uart\include;..\..\..\SDK\src\rp2_common\hardware_adc\include;..\..\..\SDK\src\common\pico_base\include;..\..\..\SDK\src\rp2_common\pico_multicore\include;..\..\..\SDK\src\common\pico_sync\include;..\..\..\SDK\src\common\pico_time\include;..\..\..\SDK\src\common\pico_util\include;..\..\..\SDK\src\common\pico_stdlib\include;..\..\..\SDK\src\rp2_common\pico_stdio\include;..\..\..\SDK\src;..\..\..\SDK\src\rp2_common\pico_runtime\include;..\..\..\SDK\src\rp2_common\pico_printf\include;..\..\..\SDK\src\rp2_common\pico_bootrom\include;..\..\..\SDK\src\rp2_common\pico_stdio\include;..\..\..\SDK\src\rp2_common\pico_stdio_uart\include;..\..\..\SDK\src\rp2_common\pico_stdio_usb\include;..\..\..\SDK\src\common\pico_binary_info\include;..\..\..\SDK\src\rp2_common\pico_stdio_semihosting\include;..\bsp\Config;..\bsp\LCD;..\..\bsp
  asm define: as above
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\RP2040_run_in_sram.sct
  link misc: as above
target AC6-DebugInSRAM (6160000::V6.16::ARMCLANG)
  device: ARMCM0P_MPU ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: template
  AfterMake: .\axf2uf2.bat
  c flags: Optim=6 OneElfS=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=3
  c define: PICO, NDEBUG, PICO_NO_FLASH,__PICO_USE_LCD_1IN3__=1
  c misc: -include env_wrapper.h
  c include: ..\..\..\SDK\src\rp2_common\hardware_flash\include\;..\..\..\SDK\src\rp2_common\hardware_dma\include\;..\..\..\SDK\src\rp2040\hardware_structs\include;..\..\..\SDK\src\rp2_common\cmsis\include\cmsis;..\..\..\SDK\src\rp2_common\cmsis\stub\CMSIS\Device\RaspberryPi\RP2040\Include;..\..\..\SDK\src\boards\include\boards;..\..\..\SDK\src\rp2040\hardware_regs\include;.\wrapper;..\..\..\SDK\src\rp2_common\hardware_base\include;..\..\..\SDK\src\rp2_common\hardware_watchdog\include;..\..\..\SDK\src\rp2_common\hardware_pll\include;..\..\..\SDK\src\rp2_common\hardware_xosc\include;..\..\..\SDK\src\rp2_common\hardware_irq\include;..\..\..\SDK\src\rp2_common\hardware_gpio\include;..\..\..\SDK\src\rp2_common\hardware_resets\include;..\..\..\SDK\src\rp2_common\hardware_clocks\include;..\..\..\SDK\src\rp2_common\hardware_timer\include;..\..\..\SDK\src\rp2_common\hardware_sync\include;..\..\..\SDK\src\rp2_common\hardware_claim\include;..\..\..\SDK\src\rp2_common\hardware_spi\include;..\..\..\SDK\src\rp2_common\hardware_pwm\include;..\..\..\SDK\src\rp2_common\hardware_i2c\include;..\..\..\SDK\src\rp2_common\hardware_uart\include;..\..\..\SDK\src\rp2_common\hardware_adc\include;..\..\..\SDK\src\common\pico_base\include;..\..\..\SDK\src\rp2_common\pico_multicore\include;..\..\..\SDK\src\common\pico_sync\include;..\..\..\SDK\src\common\pico_time\include;..\..\..\SDK\src\common\pico_util\include;..\..\..\SDK\src\common\pico_stdlib\include;..\..\..\SDK\src\rp2_common\pico_stdio\include;..\..\..\SDK\src;..\..\..\SDK\src\rp2_common\pico_runtime\include;..\..\..\SDK\src\rp2_common\pico_printf\include;..\..\..\SDK\src\rp2_common\pico_bootrom\include;..\..\..\SDK\src\rp2_common\pico_stdio\include;..\..\..\SDK\src\rp2_common\pico_stdio_uart\include;..\..\..\SDK\src\rp2_common\pico_stdio_usb\include;..\..\..\SDK\src\common\pico_binary_info\include;..\..\..\SDK\src\rp2_common\pico_stdio_semihosting\include;..\..\..\SDK\src\rp2_common\boot_stage2\include;.\wrapper\pico_base;..\bsp\Config;..\bsp\LCD;..\..\bsp
  asm define: as above
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\RP2040_debug_in_sram.sct
  link misc: --diag_suppress=L6170,L6314,L6306,L6329 --entry=Reset_Handler
target AC6-DebugInSRAM-printf (6160000::V6.16::ARMCLANG)
  device: ARMCM0P_MPU ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: template
  AfterMake: .\axf2uf2.bat
  c flags: OneElfS=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=3
  c define: PICO, NDEBUG, PICO_NO_FLASH, USE_EVR_FOR_STDOUR,__PICO_USE_LCD_1IN3__=0
  c misc: -include env_wrapper.h -Omax
  c include: as above
  asm define: as above
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\RP2040_debug_in_sram.sct
  link misc: as above
software components: CMSIS:CORE 5.4.0, Utilities:perf_counter:Core 1.9.11, Compiler:Event Recorder 1.4.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0
